IMAGE_INSTALL_remove = " \
					 pitft-init-sato \
					 xinput-calibrator \
"
IMAGE_INSTALL_append = " \
					 rpi-fbcp \
					 rpi-fbcp-init \
"